# Keil uVision project Proj_Step_1.uvproj, settings and files
target Cible_STM103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Proj_Step_1
  c flags: Optim=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: principal.c Tempo.s
    ./: etape2.s etape2_2.s Signaltest.asm
    ./Matlab/: Trigo.asm Signal.asm
  group Lib
    ./Lib/: gassp72.lib
  group Sys
    ./Systeme/: startup-rvds.s
target Cible_Simulateur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Proj_Step_1
  c flags: Optim=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
